# Keil uVision project SmartBin_A1.uvprojx, settings and files
target SmartBin_A1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: SmartBin_A1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,__MICROLIB
  c misc: -std=c11 -Wall -Wextra -Werror -Oz
  c include: ..\include;..\vendor\CMSIS5_Core;..\..\legacy\SmartBin_F103\CMSIS\Device
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\flash.sct
  link misc: --strict
  group Application
    ../src/: app.c console.c devices.c main.c nor.c platform.c rfid.c storage.c
  group Startup
    ../src/: startup.s
  group Headers
    ../include/: app.h config.h devices.h platform.h storage.h
